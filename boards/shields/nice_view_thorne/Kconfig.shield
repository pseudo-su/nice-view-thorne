## boards/shields/nice_view_thorne/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_THORNE
    def_bool $(shields_list_contains,nice_view_thorne)
```
